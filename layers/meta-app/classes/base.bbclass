do_build(){
	echo "Hello bitbake!"
}
addtask do_build